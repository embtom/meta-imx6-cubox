PACKAGECONFIG = "libkms udev etnaviv install-test-programs"